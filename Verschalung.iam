# Autodesk Inventor assembly: Verschalung
## iProperties
Created: 2006-10
Part Number: Verschalung
Document SubType Name: Weldment
Designer: rr
Author: rr
