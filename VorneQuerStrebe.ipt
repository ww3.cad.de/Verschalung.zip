# Autodesk Inventor part: VorneQuerStrebe
## iProperties
Created: 2006-10
Part Number: VorneQuerStrebe
Document SubType Name: Sheet Metal
Designer: rr
Author: rr
## Feature names
1. Grobblech1
