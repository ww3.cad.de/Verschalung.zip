# Autodesk Inventor part: KopfBogen
## iProperties
Created: 2006-10
Part Number: KopfBogen
Document SubType Name: Sheet Metal
Designer: rr
## Feature names
1. Sweeping3
