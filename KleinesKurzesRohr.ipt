# Autodesk Inventor part: KleinesKurzesRohr
## iProperties
Created: 2006-10
Part Number: KleinesKurzesRohr
Document SubType Name: Sheet Metal
Designer: rr
Author: rr
## Feature names
1. Grobblech1
