# Autodesk Inventor part: KopfRohr
## iProperties
Created: 2006-10
Part Number: KopfRohr
Document SubType Name: Sheet Metal
Designer: rr
Author: rr
## Feature names
1. Extrusion1
2. Grobblech1
