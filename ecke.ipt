# Autodesk Inventor part: ecke
## iProperties
Created: 2006-10
Part Number: ecke
Document SubType Name: Sheet Metal
Designer: rr
Author: rr
## Feature names
1. Sweeping1
