# Autodesk Inventor part: BogenHinten
## iProperties
Created: 2006-10
Part Number: BogenHinten
Document SubType Name: Sheet Metal
Designer: rr
## Feature names
1. Sweeping2
