# Autodesk Inventor part: BogenVorne
## iProperties
Created: 2006-10
Part Number: BogenVorne
Document SubType Name: Sheet Metal
Designer: rr
## Feature names
1. Sweeping2
