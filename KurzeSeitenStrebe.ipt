# Autodesk Inventor part: KurzeSeitenStrebe
## iProperties
Created: 2006-10
Part Number: KurzeSeitenStrebe
Document SubType Name: Sheet Metal
Designer: rr
Author: rr
## Feature names
1. Grobblech1
