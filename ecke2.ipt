# Autodesk Inventor part: ecke2
## iProperties
Created: 2006-10
Part Number: ecke2
Document SubType Name: Sheet Metal
Designer: rr
Author: rr
## Feature names
1. Sweeping1
