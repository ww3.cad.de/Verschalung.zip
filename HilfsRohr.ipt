# Autodesk Inventor part: HilfsRohr
## iProperties
Created: 2006-10
Part Number: HilfsRohr
Document SubType Name: Sheet Metal
Designer: rr
Author: rr
## Feature names
1. Grobblech1
