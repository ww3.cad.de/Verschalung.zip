# Autodesk Inventor part: obenRundRahmen
## iProperties
Created: 2006-10
Part Number: obenRundRahmen
Document SubType Name: Sheet Metal
Designer: rr
## Feature names
1. Sweeping2
